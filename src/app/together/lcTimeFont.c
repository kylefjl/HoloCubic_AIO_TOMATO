/*
*---------------------------------------------------------------
*                        Lvgl Font Tool                         
*                                                               
* 注:使用unicode编码                                              
* 注:本字体文件由Lvgl Font Tool V0.4 生成                          
* 作者:阿里(qq:617622104)                                         
*---------------------------------------------------------------
*/


#include "lvgl.h"


static const uint8_t glyph_bitmap[] = {
/*   */



/* 0 */
0x00,0x02,0x53,0x00,0x00,  //...+*+...
0x00,0x7b,0x7a,0x90,0x00,  //..*@*%%+.
0x03,0xb0,0x00,0x96,0x00,  //.*@+..%*.
0x0a,0x30,0x00,0x1c,0x00,  //.%+...+@.
0x0c,0x00,0x00,0x0b,0x10,  //+@.....@+
0x29,0x00,0x00,0x09,0x30,  //+%.....%+
0x49,0x00,0x00,0x0a,0x30,  //*%.....%+
0x2a,0x00,0x00,0x0c,0x00,  //+%.....@+
0x0c,0x00,0x00,0x2a,0x00,  //+@+...+%.
0x08,0x70,0x00,0xb3,0x00,  //.%*..+@+.
0x00,0x9c,0xac,0x50,0x00,  //.+%@%@*..
0x00,0x01,0x20,0x00,0x00,  //...+++...


/* 1 */
0x00,0x00,0x00,  //..+..
0x02,0xd2,0x00,  //.+@+.
0x0c,0xa4,0x00,  //+@%*.
0x02,0x84,0x00,  //.+%*.
0x00,0x83,0x00,  //..%+.
0x00,0x83,0x00,  //..%+.
0x00,0x93,0x00,  //..%+.
0x00,0x92,0x00,  //..%+.
0x00,0x92,0x00,  //..%+.
0x00,0x92,0x00,  //..%+.
0x0b,0xdc,0x40,  //+@@@*


/* 2 */
0x00,0x00,0x00,  //......
0x04,0xbc,0x80,  //.*%@%+
0x5b,0x20,0x78,  //*@++*%
0x30,0x00,0x39,  //++..+%
0x00,0x00,0xb3,  //...+%+
0x00,0x08,0x80,  //...%%.
0x00,0x6a,0x00,  //..*%+.
0x05,0xb0,0x00,  //.*@+..
0x2c,0x00,0x00,  //+@+...
0x94,0x00,0x00,  //%*....
0x9c,0xcc,0xc8,  //%@@@@%


/* 3 */
0x00,0x5a,0xb9,0x10,  //..*%@%+
0x00,0x73,0x06,0x70,  //.+%++*%
0x00,0x00,0x07,0x70,  //.....**
0x00,0x02,0x8b,0x00,  //...+%@+
0x00,0x0a,0xd6,0x00,  //...%@*.
0x00,0x00,0x0b,0x40,  //....+%*
0x00,0x00,0x03,0x90,  //.....+%
0x00,0x00,0x02,0x90,  //.....+%
0x3a,0x10,0x09,0x50,  //+%+.+%*
0x04,0xbd,0xd7,0x00,  //.*@@@*.
0x00,0x00,0x00,0x00,  //...++..


/* 4 */
0x00,0x00,0x00,0x00,  //....++.
0x00,0x00,0xa2,0x00,  //....%+.
0x00,0x02,0xb0,0x00,  //...+@..
0x00,0x0a,0x40,0x00,  //...%*..
0x00,0x2b,0x00,0x00,  //..+@...
0x00,0xa3,0x27,0x00,  //..%++%.
0x03,0xa0,0x39,0x00,  //.*%.+%.
0x0b,0x20,0x2a,0x00,  //.@+.+%.
0x1e,0xcc,0xce,0x50,  //+@@@@@*
0x00,0x00,0x2b,0x00,  //..+++@+
0x00,0x00,0x0b,0x00,  //....+@.
0x00,0x00,0x00,0x00,  //.....+.


/* 5 */
0x01,0x11,0x22,0x00,  //.++++++
0x2d,0xba,0xaa,0x20,  //+@@%%%+
0x09,0x30,0x00,0x00,  //.%+....
0x09,0x30,0x00,0x00,  //.%+....
0x09,0xaa,0x70,0x00,  //.%%%*+.
0x09,0x72,0x7a,0x00,  //.%*+*%+
0x00,0x00,0x09,0x40,  //.+...%*
0x00,0x00,0x06,0x70,  //.....**
0x00,0x00,0x09,0x40,  //.....%*
0x15,0x00,0x5b,0x00,  //+*++*@+
0x08,0xdc,0x80,0x00,  //+%@@%+.
0x00,0x00,0x00,0x00,  //.......


/* 6 */
0x00,0x00,0x10,0x00,  //....+...
0x00,0x08,0x90,0x00,  //..+%%...
0x00,0x87,0x00,0x00,  //..%%....
0x04,0xa0,0x00,0x00,  //.*%.....
0x0b,0x21,0x20,0x00,  //.@++++..
0x1c,0xab,0xab,0x10,  //+@%@%@+.
0x3e,0x40,0x04,0xa0,  //+@*..*%.
0x29,0x00,0x00,0xd0,  //+%....@+
0x0c,0x00,0x00,0xc0,  //+@+...@+
0x05,0xa1,0x06,0xa0,  //.*%++*%.
0x00,0x6c,0xc8,0x00,  //..*@@%+.


/* 7 */
0x00,0x00,0x00,0x00,  //.....++
0x0b,0xcc,0xcd,0xa0,  //+@@@@@%
0x00,0x00,0x07,0x60,  //.....**
0x00,0x00,0x0c,0x00,  //....+@+
0x00,0x00,0x76,0x00,  //....**.
0x00,0x00,0xc0,0x00,  //...+@+.
0x00,0x04,0x90,0x00,  //...*%..
0x00,0x09,0x40,0x00,  //...%*..
0x00,0x0c,0x00,0x00,  //...@+..
0x00,0x0c,0x00,0x00,  //..+@...
0x00,0x2a,0x00,0x00,  //..+%...
0x00,0x00,0x00,0x00,  //..++...


/* 8 */
0x00,0x00,0x30,0x00,  //...+++..
0x00,0x6c,0x9c,0x10,  //..*@%@+.
0x01,0xc0,0x07,0x50,  //.+@+.%*.
0x01,0xb0,0x0b,0x10,  //.+@.+@+.
0x00,0x79,0x97,0x00,  //..%%%%..
0x00,0x1d,0xd1,0x00,  //..+@@+..
0x01,0xc4,0x4c,0x00,  //.+@**@+.
0x0a,0x40,0x08,0x60,  //.%*..%*.
0x0c,0x00,0x01,0xb0,  //+@...+@.
0x0c,0x10,0x03,0xa0,  //.@+..+%.
0x04,0xda,0xac,0x20,  //.*@%%@+.
0x00,0x02,0x20,0x00,  //..++++..


/* 9 */
0x00,0x8c,0x81,0x00,  //.+%@%+.
0x0b,0x51,0x5b,0x00,  //+@*+*@+
0x48,0x00,0x07,0x60,  //*%...**
0x66,0x00,0x01,0xa0,  //**...+%
0x3a,0x00,0x06,0xb0,  //+%..+*@
0x08,0xb8,0xbc,0x90,  //.%@%@@%
0x00,0x24,0x1a,0x40,  //..+*+%*
0x00,0x00,0x4b,0x00,  //....*@.
0x00,0x03,0xd2,0x00,  //...+@+.
0x00,0x5c,0x20,0x00,  //..*@+..
0x00,0x20,0x00,0x00,  //..++...


/* 业 */
0x00,0x00,0x05,0x00,0x13,0x00,0x00,0x00,  //.....*..+*.....
0x00,0x00,0x0a,0x00,0x37,0x00,0x00,0x00,  //.....%..+%.....
0x05,0x00,0x0a,0x00,0x37,0x00,0x33,0x00,  //.*+..%..+%..++.
0x07,0x30,0x0a,0x00,0x37,0x00,0x83,0x00,  //.%+..%..+%..%+.
0x03,0x70,0x0a,0x00,0x37,0x00,0xa0,0x00,  //.+%..%..+%..%+.
0x00,0xb0,0x0a,0x00,0x37,0x00,0xb0,0x00,  //.+@..%..+%.+@..
0x00,0xa0,0x0a,0x00,0x37,0x03,0x90,0x00,  //..%+.%..+%.+%..
0x00,0x74,0x0a,0x00,0x37,0x07,0x40,0x00,  //..**.%..+%.**..
0x00,0x37,0x0a,0x00,0x37,0x0b,0x00,0x00,  //..+%.%..+%.@+..
0x00,0x0a,0x0a,0x00,0x37,0x29,0x00,0x00,  //..+%.%..+%+%...
0x00,0x06,0x0a,0x00,0x37,0x63,0x00,0x00,  //...*.%..+%*+...
0x00,0x00,0x0a,0x00,0x37,0x00,0x00,0x00,  //.....%..+%.....
0x00,0x00,0x0a,0x00,0x37,0x00,0x00,0x00,  //.....%..+%.....
0x3a,0xaa,0xab,0xaa,0xab,0xaa,0xaa,0x00,  //+%%%%%%%%%%%%%+


/* 天 */
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,  //..+++++++++++..
0x00,0x9a,0xaa,0xad,0xaa,0xaa,0xa1,0x00,  //..%%%%%@%%%%%+.
0x00,0x00,0x00,0x0a,0x00,0x00,0x00,0x00,  //.......%.......
0x00,0x00,0x00,0x0a,0x00,0x00,0x00,0x00,  //.......%.......
0x00,0x00,0x00,0x0a,0x00,0x00,0x00,0x00,  //.......%.......
0x08,0x88,0x88,0x8d,0x88,0x88,0x88,0x00,  //+%%%%%%@%%%%%%+
0x02,0x22,0x22,0x2e,0x62,0x22,0x22,0x00,  //.++++++@*+++++.
0x00,0x00,0x00,0x1b,0xb0,0x00,0x00,0x00,  //......+@%......
0x00,0x00,0x00,0x65,0x94,0x00,0x00,0x00,  //......**%*.....
0x00,0x00,0x00,0xc0,0x1c,0x10,0x00,0x00,  //.....+@++@+....
0x00,0x00,0x09,0x60,0x04,0xa0,0x00,0x00,  //.....%*..*%+...
0x00,0x00,0x89,0x00,0x00,0x5a,0x00,0x00,  //...+%%....*%+..
0x00,0x4c,0x70,0x00,0x00,0x04,0xb3,0x00,  //.+*@*+.....*@+.
0x0a,0x81,0x00,0x00,0x00,0x00,0x19,0x20,  //.%%+........+%+


/* 已 */
0x01,0x22,0x22,0x22,0x22,0x21,0x00,0x00,  //.+++++++++++...
0x06,0x88,0x88,0x88,0x88,0x8b,0x40,0x00,  //.*%%%%%%%%%@*..
0x00,0x00,0x00,0x00,0x00,0x04,0x60,0x00,  //...........**..
0x00,0x00,0x00,0x00,0x00,0x04,0x60,0x00,  //...........**..
0x01,0x00,0x00,0x00,0x00,0x04,0x60,0x00,  //.+.........**..
0x08,0x10,0x00,0x00,0x00,0x04,0x60,0x00,  //.%+........**..
0x08,0x87,0x77,0x77,0x77,0x7a,0x40,0x00,  //.%%%%%%%%%%%*..
0x08,0x42,0x22,0x22,0x22,0x21,0x00,0x00,  //.%*+++++++++...
0x08,0x10,0x00,0x00,0x00,0x00,0x00,0x00,  //.%+............
0x08,0x10,0x00,0x00,0x00,0x00,0x05,0x00,  //.%+..........*+
0x08,0x10,0x00,0x00,0x00,0x00,0x09,0x10,  //.%+..........%+
0x08,0x10,0x00,0x00,0x00,0x00,0x0a,0x00,  //.%+..........%+
0x08,0x30,0x00,0x00,0x00,0x00,0x1a,0x00,  //.%+.........+%.
0x02,0xaa,0xaa,0xaa,0xaa,0xaa,0xa2,0x00,  //.+%%%%%%%%%%%+.
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,  //...............


/* 秒 */
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,  //...............
0x00,0x00,0x23,0x00,0x05,0x10,0x00,0x00,  //...+++...*+....
0x07,0xbc,0x73,0x00,0x07,0x30,0x00,0x00,  //.%%@%+.+.%+++..
0x00,0x09,0x00,0x0a,0x07,0x32,0x80,0x00,  //..+%...%.%++%..
0x00,0x09,0x00,0x09,0x07,0x30,0xb0,0x00,  //..+%..+%.%+.%+.
0x2a,0xad,0xaa,0x46,0x07,0x30,0x65,0x00,  //+%%@%%**.%+.**.
0x00,0x3b,0x00,0x82,0x07,0x30,0x1a,0x00,  //..+@..%+.%+.+%.
0x00,0x8e,0x40,0xa0,0x07,0x30,0x0a,0x00,  //..%@*+%..%+..%+
0x01,0xba,0xa4,0x60,0x07,0x30,0x68,0x30,  //.+@%%**..%+.*%+
0x09,0x49,0x67,0x00,0x07,0x30,0xa1,0x20,  //.%*%**+..%+.%++
0x48,0x09,0x00,0x00,0x07,0x31,0xa0,0x00,  //*%+%.....%++%..
0x60,0x09,0x00,0x00,0x04,0x18,0x40,0x00,  //*++%.....*+%*..
0x00,0x09,0x00,0x00,0x00,0x59,0x00,0x00,  //..+%......*%...
0x00,0x09,0x00,0x00,0x29,0x80,0x00,0x00,  //..+%....+%%+...
0x00,0x09,0x03,0xaa,0x82,0x00,0x00,0x00,  //..+%.+%%%+.....
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,  //...+.++........


/* 营 */
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,  //...............
0x00,0x00,0x51,0x00,0x03,0x20,0x00,0x00,  //....*+...++....
0x01,0x11,0x83,0x11,0x16,0x51,0x10,0x00,  //.+++%++++**+++.
0x08,0x99,0xca,0x99,0x9b,0xb9,0x96,0x00,  //+%%%@%%%%@%%%*.
0x00,0x00,0x72,0x00,0x05,0x40,0x00,0x00,  //....%+...**....
0x02,0x77,0x77,0x77,0x77,0x77,0x76,0x00,  //.+*%%%%%%%%%%*+
0x0b,0x33,0x33,0x33,0x33,0x33,0x39,0x30,  //.%*++++++++++%*
0x0a,0x07,0x99,0x99,0x99,0x98,0x0a,0x10,  //.%+*%%%%%%%%+%+
0x07,0x2a,0x11,0x11,0x11,0x18,0x56,0x00,  //.*+%+++++++%**.
0x00,0x2b,0x44,0x44,0x44,0x49,0x40,0x00,  //..+@*******%*..
0x00,0x04,0x66,0x66,0x66,0x65,0x00,0x00,  //...*********+..
0x00,0x59,0x99,0x99,0x99,0x99,0x60,0x00,  //..*%%%%%%%%%*..
0x00,0xb1,0x00,0x00,0x00,0x01,0xb0,0x00,  //..@+++++++++@+.
0x00,0xb1,0x00,0x00,0x00,0x01,0xb0,0x00,  //..@+++++++++@+.
0x00,0x69,0x99,0x99,0x99,0x99,0x70,0x00,  //..*%%%%%%%%%*..


};


static const lv_font_fmt_txt_glyph_dsc_t glyph_dsc[] = {
    {.bitmap_index = 0,	.adv_w = 8, .box_h = 0, .box_w = 8, .ofs_x = 0, .ofs_y = 5},/*( )*/
    {.bitmap_index = 0,	.adv_w = 9, .box_h = 12, .box_w = 10, .ofs_x = 0, .ofs_y = 4},/*(0)*/
    {.bitmap_index = 60,	.adv_w = 5, .box_h = 11, .box_w = 6, .ofs_x = 0, .ofs_y = 5},/*(1)*/
    {.bitmap_index = 93,	.adv_w = 7, .box_h = 11, .box_w = 6, .ofs_x = 1, .ofs_y = 5},/*(2)*/
    {.bitmap_index = 126,	.adv_w = 7, .box_h = 11, .box_w = 8, .ofs_x = 0, .ofs_y = 4},/*(3)*/
    {.bitmap_index = 170,	.adv_w = 7, .box_h = 12, .box_w = 8, .ofs_x = 0, .ofs_y = 4},/*(4)*/
    {.bitmap_index = 218,	.adv_w = 7, .box_h = 12, .box_w = 8, .ofs_x = 0, .ofs_y = 4},/*(5)*/
    {.bitmap_index = 266,	.adv_w = 8, .box_h = 11, .box_w = 8, .ofs_x = 0, .ofs_y = 5},/*(6)*/
    {.bitmap_index = 310,	.adv_w = 7, .box_h = 12, .box_w = 8, .ofs_x = 0, .ofs_y = 4},/*(7)*/
    {.bitmap_index = 358,	.adv_w = 8, .box_h = 12, .box_w = 8, .ofs_x = 0, .ofs_y = 4},/*(8)*/
    {.bitmap_index = 406,	.adv_w = 7, .box_h = 11, .box_w = 8, .ofs_x = 0, .ofs_y = 4},/*(9)*/
    {.bitmap_index = 450,	.adv_w = 15, .box_h = 14, .box_w = 16, .ofs_x = 0, .ofs_y = 3},/*(业)*/
    {.bitmap_index = 562,	.adv_w = 15, .box_h = 14, .box_w = 16, .ofs_x = 0, .ofs_y = 3},/*(天)*/
    {.bitmap_index = 674,	.adv_w = 15, .box_h = 15, .box_w = 16, .ofs_x = 0, .ofs_y = 2},/*(已)*/
    {.bitmap_index = 794,	.adv_w = 15, .box_h = 16, .box_w = 16, .ofs_x = 0, .ofs_y = 2},/*(秒)*/
    {.bitmap_index = 922,	.adv_w = 15, .box_h = 15, .box_w = 16, .ofs_x = 0, .ofs_y = 3},/*(营)*/
};


static const uint16_t unicode_list_1[] = {
    0x0020,	/*( )*/
    0x0030,	/*(0)*/
    0x0031,	/*(1)*/
    0x0032,	/*(2)*/
    0x0033,	/*(3)*/
    0x0034,	/*(4)*/
    0x0035,	/*(5)*/
    0x0036,	/*(6)*/
    0x0037,	/*(7)*/
    0x0038,	/*(8)*/
    0x0039,	/*(9)*/
    0x4e1a,	/*(业)*/
    0x5929,	/*(天)*/
    0x5df2,	/*(已)*/
    0x79d2,	/*(秒)*/
    0x8425,	/*(营)*/
    0x0000,    /*End indicator*/
};


static const lv_font_fmt_txt_cmap_t cmaps[] = {
    {
        .range_start = 0x0020,
        .range_length = 0x8425,
        .type = LV_FONT_FMT_TXT_CMAP_SPARSE_TINY,
        .glyph_id_start = 0,
        .unicode_list = unicode_list_1,
        .glyph_id_ofs_list = NULL,
        .list_length = 16,
    }
};


static lv_font_fmt_txt_dsc_t font_dsc = {
    .glyph_bitmap = glyph_bitmap,
    .glyph_dsc = glyph_dsc,
    .cmaps = cmaps,
    .cmap_num = 1,
    .bpp = 4,

    .kern_scale = 0,
    .kern_dsc = NULL,
    .kern_classes = 0,

    .last_letter = 0x8425,
    .last_glyph_id = 15,
};


static int binsearch(const uint16_t *sortedSeq, int seqLength, uint16_t keyData) {
    int low = 0, mid, high = seqLength - 1;
    while (low <= high) {
        mid = (low + high)>>1;//右移1位等于是/2，奇数，无论奇偶，有个值就行
        if (keyData < sortedSeq[mid]) {
            high = mid - 1;//是mid-1，因为mid已经比较过了
        }
        else if (keyData > sortedSeq[mid]) {
            low = mid + 1;
        }
        else {
            return mid;
        }
    }
    return -1;
}


static const uint8_t * __user_font_get_bitmap(const lv_font_t * font, uint32_t unicode_letter) {
    lv_font_fmt_txt_dsc_t * fdsc = (lv_font_fmt_txt_dsc_t *) font->dsc;

    if( unicode_letter<fdsc->cmaps[0].range_start || unicode_letter>fdsc->cmaps[0].range_length ) return false;

    int i;
    if( unicode_letter==fdsc->last_letter ){
        i = fdsc->last_glyph_id;
    }
    else{
        i = binsearch(fdsc->cmaps[0].unicode_list, fdsc->cmaps[0].list_length, unicode_letter);
    }
    if( i != -1 ) {
        const lv_font_fmt_txt_glyph_dsc_t * gdsc = &fdsc->glyph_dsc[i];
        fdsc->last_glyph_id = i;
        fdsc->last_letter = unicode_letter;
        return &fdsc->glyph_bitmap[gdsc->bitmap_index];
    }
    return NULL;
}


static bool __user_font_get_glyph_dsc(const lv_font_t * font, lv_font_glyph_dsc_t * dsc_out, uint32_t unicode_letter, uint32_t unicode_letter_next) {
    lv_font_fmt_txt_dsc_t * fdsc = (lv_font_fmt_txt_dsc_t *) font->dsc;

    if( unicode_letter<fdsc->cmaps[0].range_start || unicode_letter>fdsc->cmaps[0].range_length ) return false;

    int i;
    if( unicode_letter==fdsc->last_letter ){
        i = fdsc->last_glyph_id;
    }
    else{
        i = binsearch(fdsc->cmaps[0].unicode_list, fdsc->cmaps[0].list_length, unicode_letter);
    }
    if( i != -1 ) {
        const lv_font_fmt_txt_glyph_dsc_t * gdsc = &fdsc->glyph_dsc[i];
        fdsc->last_glyph_id = i;
        fdsc->last_letter = unicode_letter;
        dsc_out->adv_w = gdsc->adv_w;
        dsc_out->box_h = gdsc->box_h;
        dsc_out->box_w = gdsc->box_w;
        dsc_out->ofs_x = gdsc->ofs_x;
        dsc_out->ofs_y = gdsc->ofs_y;
        dsc_out->bpp   = fdsc->bpp;
        return true;
    }
    return false;
}


//微软雅黑,Regular,12
//字模高度：17
//内部字体
//使用排序和二分查表
lv_font_t lcTimeFont = {
    .dsc = &font_dsc,
    .get_glyph_bitmap = __user_font_get_bitmap,
    .get_glyph_dsc = __user_font_get_glyph_dsc,
    .line_height = 17,
    .base_line = 0,
};

